options:
  parameters:
    author: Multi-Coherent KiwiSDR contributors
    description: Pojedynczy odbiornik KiwiSDR - widmo IQ
    generate_options: qt_gui
    id: kiwisdr_single_rx
    output_language: python
    title: KiwiSDR Multi-Coherent - Single RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: kiwisdr_source_0
  id: multi_kiwisdr_source
  parameters:
    agc_on: 'True'
    bandwidth_hz: '10000'
    comment: Polacz z KiwiSDR i odbieraj IQ
    freq_mhz: '9.996'
    host: '"kiwisdr-dorohoi.ddns.net"'
    man_gain: '50'
    port: '8073'
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Widmo PSD (FFT)
    fc: '9996000'
    fftsize: '1024'
    grid: 'True'
    label: KiwiSDR IQ PSD
    name: '"KiwiSDR @ 9.996 MHz"'
    tr_level: '-40.0'
    type: complex
  states: {}
- name: qtgui_freq_sink_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Widmo PSD (FFT)
    fc: '9996000'
    fftsize: '1024'
    grid: 'True'
    label: KiwiSDR IQ PSD
    name: '"KiwiSDR @ 9.996 MHz"'
    tr_level: '-40.0'
    type: complex
  states: {}
- name: qtgui_freq_sink_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Widmo PSD (FFT)
    fc: '9996000'
    fftsize: '1024'
    grid: 'True'
    label: KiwiSDR IQ PSD
    name: '"KiwiSDR @ 9.996 MHz"'
    tr_level: '-40.0'
    type: complex
  states: {}
- name: qtgui_freq_sink_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Widmo PSD (FFT)
    fc: '9996000'
    fftsize: '1024'
    grid: 'True'
    label: KiwiSDR IQ PSD
    name: '"KiwiSDR @ 9.996 MHz"'
    tr_level: '-40.0'
    type: complex
  states: {}
- name: qtgui_freq_sink_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Widmo PSD (FFT)
    fc: '9996000'
    fftsize: '1024'
    grid: 'True'
    label: KiwiSDR IQ PSD
    name: '"KiwiSDR @ 9.996 MHz"'
    tr_level: '-40.0'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Waterfall
    fc: '9996000'
    fftsize: '1024'
    name: '"Waterfall KiwiSDR"'
    type: complex
  states: {}
- name: multi_kiwisdr_multi_source_0
  id: multi_kiwisdr_multi_source
  parameters:
    bandwidth_hz: '10000'
    freq_mhz: '9.996'
    hosts_csv: '"kiwisdr-dorohoi.ddns.net,22152.proxy.kiwisdr.com,22315.proxy.kiwisdr.com"'
    num_ch: '3'
    port: '8073'
  states: {}
- name: multi_kiwisdr_wideband_0
  id: multi_kiwisdr_wideband
  parameters:
    center_mhz: '9.996'
    host: '"22315.proxy.kiwisdr.com"'
    num_slots: '3'
    overlap_hz: '1000'
    port: '8073'
    slot_bw_hz: '10000'
  states: {state: disabled}

connections:
- [kiwisdr_source_0, '0', qtgui_freq_sink_0, '0']
- [kiwisdr_source_0, '0', qtgui_waterfall_sink_0, '0']
- [multi_kiwisdr_multi_source_0, '0', qtgui_freq_sink_0_0, '0']
- [multi_kiwisdr_multi_source_0, '1', qtgui_freq_sink_0_0_0, '0']
- [multi_kiwisdr_multi_source_0, '2', qtgui_freq_sink_0_0_1, '0']
- [multi_kiwisdr_wideband_0, '0', qtgui_freq_sink_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
